# IAR project test.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F4XX
  ICCARM.CCIncludePath2: ..\STM32F4xx_StdPeriph_Driver\inc; ..\STM32F4-Discovery; ..\User; ..\Core; ..\System\sys; ..\System\delay; ..\System\usart; ..\STM32F4-Discovery\led; ..\STM32F4-Discovery\key; ..\STM32F4-Discovery\exti; ..\STM32F4-Discovery\wwdg; ..\STM32F4-Discovery\timer; ..\STM32F4-Discovery\pwm
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: test.hex
  ILINK.IlinkOutputFile: test.out
  ILINK.IlinkIcfFile: test.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group EWARM
    ./: startup_stm32f4xx.s
  group STM32F4-Discovery
    ../STM32F4-Discovery/: stm32f4_discovery.c
  group STM32F4-Discovery/Exti
    ../STM32F4-Discovery/exti/: exti.c
  group STM32F4-Discovery/Iwdg
    ../User/: iwdg.c
  group STM32F4-Discovery/Key
    ../STM32F4-Discovery/key/: key.c
  group STM32F4-Discovery/Led
    ../STM32F4-Discovery/led/: led.c
  group STM32F4-Discovery/Pwm
    ../STM32F4-Discovery/pwm/: pwm.c
  group STM32F4-Discovery/Timer
    ../STM32F4-Discovery/timer/: timer.c
  group STM32F4-Discovery/Wwdg
    ../STM32F4-Discovery/wwdg/: wwdg.c
  group STM32F4xx_StdPeriph_Driver
    ../STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_iwdg.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group System
    ../System/delay/: delay.c
    ../System/sys/: sys.c
    ../System/usart/: usart.c
  group User
    ../User/: main.c stm32f4xx_it.c system_stm32f4xx.c
